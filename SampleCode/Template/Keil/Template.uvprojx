# Keil uVision project Template.uvprojx, settings and files
target ENABLE_UART0 (6120000::V6.12::.\ARMCLANG)
  device: NUC1262SE4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: ENABLE_UART0
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUC1262\Include;..\..\..\Library\StdDriver\inc;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1262.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC1262/Source/: system_NUC1262.c
    ../../../Library/Device/Nuvoton/NUC1262/Source/ARM/: startup_NUC1262.s
  group User
    ../: main.c misc_config.c cdc_serial.c descriptors.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c timer.c usbd.c
target ENABLE_UART1 (6120000::V6.12::.\ARMCLANG)
  device: NUC1262SE4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: as above
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: ENABLE_UART1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: as above
